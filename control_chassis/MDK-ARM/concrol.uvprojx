# Keil uVision project concrol.uvprojx, settings and files
target concrol (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: concrol +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,REMOTE_BACKEND_A28_E34=1,REMOTE_BACKEND_FLYSKY_IBUS=0
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: flash_storage.c main.c gpio.c freertos.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Core/UserDev
    ../Core/UserDev/: cruise_control.c grass_bag_control.c lifter.c sr04_uart.c AXEBMS_RS485.c icm42688.c pairing_receiver.c BladeMotor.c flipsky_can.c bsp_imu_solver.c EG2104.c heartbeat.c modbus_rtu_bus.c mssd_can.c can_tx_scheduler.c can_tx_port.c odrive_can.c tricolor_led.c buzzer.c connet_check.c E34.C A28.c remote_backend.c flysky_ibus_servo.c sens_ibus_responder.c sens_ibus_usart2.c blade_hil_uart_debug.c remote_authorization.c blade_confirm_ch6_adapter.c read_adc.c rs485.c serial_port.c chassis_control.c oid_can.c
  group Application/User/Core/UserAPP
    ../Core/UserApp/: app_context.c control_source.c safety_ownership_gate.c blade_manual_control.c app_imu.c app_Motion.c app_Comm.c app_BMS_Sensor.c app_Report.c app_SerialTX.c battery_monitor.c telemetry_snapshot.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Shared blade OK protocol
    ../../experiments/ticket03/: exp3.c exp3_link.c exp3_hil.c stm32_adapter.c exp3_probe.c exp3_blade_adapter.c exp3_auto_session.c
software components: CMSIS:CORE 5.6.0
